Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2]
File name: N:\2000\316762_HKI_DIMA_koordinointi_6_2022_5_2023\4_Tuote\Kaupunkikalusteiden 3D mallit\IFC\IFC\C3_HKI_informaatiotaulu.ifc
Time: 2022-08-31T15:17:29
Author: FITK31777
Organization: WSP
Written by: ggRhinoIFC v2.2.11.0 by Geometry Gym Pty Ltd built 2022-05-25T11:32:32
Made in: ggRhinoIFC v2.2.11.0 - Rhino7 Plug-in by Geometry Gym Pty Ltd
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcBuildingElementProxy (295)
In: By Parent
Name | IfcRoot_Description | IfcElement_Tag | IfcEntity
134 x C3_HKI_informaatiotaulu | Vetoniitti, 4,0x12 ruostumaton teräs A2 | vetoniitti | IfcFastener
49 x C3_HKI_informaatiotaulu
44 x C3_HKI_informaatiotaulu | Kumi 1mm | kumi | IfcFurnishingElement
10 x C3_HKI_informaatiotaulu | Teräslevy 6mm | teräslevy | IfcFurnishingElement
4 x C3_HKI_informaatiotaulu | Alumiinilevy 1mm | alumiinilevy | IfcFurnishingElement
37 x C3_HKI_informaatiotaulu | Teräslevy 4mm | teräslevy | IfcFurnishingElement
3 x C3_HKI_informaatiotaulu | Teräslevy 1,5mm | teräslevy | IfcFurnishingElement
3 x C3_HKI_informaatiotaulu | RHS50x30x3 |  | IfcFurnishingElement
5 x C3_HKI_informaatiotaulu | T-profiili 80x80x9 |  | IfcFurnishingElement
6 x C3_HKI_informaatiotaulu | L -profiili 75x50x7 |  | IfcFurnishingElement
